# Keil uVision project KFile.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KFile +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWLIB\inc;..\User;..\User\Fwlib;..\User\Sys;..\User\watch\includes;..\DSPLIB\Include;..\User\Fwlib\MPU6050\IIC;..\User\Fwlib\MPU6050;..\User\Fwlib\MPU6050\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group START
    ../Libraries/CMSIS/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../Libraries/FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USERBSP
    ../User/Fwlib/: tim2.c usart.c systick.c oled.c oled_funt.c wq_flash.c
    ../User/watch/devices/: battery.c buttons.c buzzer.c led.c ds3231.c
    ../User/watch/drivers/: i2c.c spi.c rtc.c
    ../User/Fwlib/MPU6050/: MAX1302.c MPU6050.c BMP280.c
    ../User/Fwlib/MPU6050/IIC/: DEV_IIC.c
    ../User/Fwlib/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group USER
    ../User/: main.c stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h
    ../User/Sys/: sys.c
    ../DSPLIB/: arm_cortexM3l_math.lib
  group Nwatch
    ../User/watch/apps/: btrccar.c calc.c screenshot.c stopwatch.c torch.c
    ../User/watch/games/: game1.c game2.c
    ../User/watch/menus/: alarms.c diag.c games.c m_main.c settings.c sleep.c sound.c timedate.c m_display.c heart.c pressure.c gyroscope.c letter.c
    ../User/watch/watchfaces/: lowbatt.c normal.c segment.c small.c ui.c
    ../User/watch/: alarm.c animation.c appconfig.c disco.c discos.c draw.c global.c menu.c pwrmgr.c resources.c system.c time.c tune.c tunes.c display.c
